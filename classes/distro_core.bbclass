
FEATURE_PACKAGES_switch = "packagegroup-s57-switch"
FEATURE_PACKAGES_gateway = "packagegroup-s57-gateway"

inherit core-image
